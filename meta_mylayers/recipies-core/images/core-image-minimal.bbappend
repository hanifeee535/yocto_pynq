#Add packages to the image:
IMAGE_INSTALL_append = "\
	helloWorld \
	"
